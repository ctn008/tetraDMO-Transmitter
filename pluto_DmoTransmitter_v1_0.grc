options:
  parameters:
    generate_options: qt_gui
    id: pluto_DmoTransmitter_v1_0
    output_language: python
    title: pluto_DmoTransmitter_v1_0
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '9'
  states: {}
- name: freq_adjust
  id: variable_qtgui_range
  parameters:
    start: '-7000'
    step: '10'
    stop: '7000'
    value: '4000'
  states: {}
- name: frequency_hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [Hz]
    type: real
    value: '390000000'
  states: {}
- name: num_tap
  id: variable
  parameters:
    value: '11'
  states: {}
- name: ptt_on
  id: variable_qtgui_push_button
  parameters:
    label: Push_To_Talk
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80000*decim
  states: {}
- name: showTxt
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: showText
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {state: disabled}
- name: symbol_rate
  id: variable
  parameters:
    value: '18000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: tetraDmoEncoder

      perform encoding Dmo tetra signal
      - input: 432 byte frames voice signal one per 4 time slot per 17 frame
      - output 510 byte tetra burst signal, 4 per frame per 18 frame
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *
      import pmt

      class DmoEncoder(gr.basic_block):

          MacEncoderLib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Transmitter/libs/MacEncoderLib_v1.so')
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.uint8, 
                                                    ndim=1,
                                                    flags="C")
          def Init_serviceMacEncode(show_txt, talkgroup_id, radio_id):
              DmoEncoder.MacEncoderLib.Init_serviceMacEncode.argtypes = [c_bool, c_size_t, c_size_t]
              DmoEncoder.MacEncoderLib.Init_serviceMacEncode(show_txt, talkgroup_id, radio_id)
            
          def serviceMacEncode(showTxt, ptt, talkgroup_id, radio_id, in_data, in_len, out_data, out_envelop):
              DmoEncoder.MacEncoderLib.serviceMacEncode.argtypes = [c_bool, c_bool, c_size_t, c_size_t, DmoEncoder.ND_POINTER, c_size_t, DmoEncoder.ND_POINTER, DmoEncoder.ND_POINTER]
              DmoEncoder.MacEncoderLib.serviceMacEncode.restype = c_size_t
              res = DmoEncoder.MacEncoderLib.serviceMacEncode(showTxt, ptt, talkgroup_id, radio_id, in_data, in_len, out_data, out_envelop)
              return res
          
          def __init__(self, show_txt=True, talkgroup_id = 1001, radio_id =6081751, ptt = False):
              gr.basic_block.__init__(
                  self,
                  name='TetraDMO Encoder',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8, np.uint8]
              )
              self.showTxt        = show_txt
              self.prev_showTxt    = False
              self.update_showTxt = False
              self.talkgroupId    = talkgroup_id
              self.radioId        = radio_id
              self.ptt            = ptt
              self.prev_ptt       = False
              self.update_ptt     = False

              self.message_port_register_in(pmt.intern('ptt'))
              self.set_msg_handler(pmt.intern('ptt'), self.handle_msg)

              self.message_port_register_out(pmt.intern('tx_keyed'))
              self.tx_keyed_status = pmt.cons( pmt.intern('tx_keyed'), pmt.from_bool(False) )

          def handle_msg(self, msg):
              # rotate curChannel + 1
              #self.ptt = True       
              print(msg)
              
          def general_work(self, input_items, output_items):
              if self.showTxt != self.prev_showTxt:
                  self.prev_showTxt = self.showTxt
                  self.update_showTxt = True
              if self.update_showTxt:
                  self.update_showTxt = False
                  print("showTxt = ", self.ptt)
              
              in_len  = len(input_items[0])
              out_len = len(output_items[0])
              in_ptr = 0
              out_ptr = 0

              in_ptr  = in_len if (out_len*2-255) >= (in_len*5) else (out_len*2-255)//5
              out_ptr = DmoEncoder.serviceMacEncode(self.showTxt, self.ptt, self.talkgroupId, self.radioId, input_items[0], in_ptr, output_items[0], output_items[1])

              self.consume(0, in_ptr)
              return out_ptr
    ptt: ptt_on
    radio_id: '6081751'
    show_txt: 'False'
    talkgroup_id: '1001'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:
      sync block, 480 samples in, 480 samples out
      """

      import numpy as np
      from gnuradio import gr
      from ctypes import *

      IN_STEP = 480
      OUT_STEP = 432
      L_FRAME     = 240
      SERIAL_SIZE = 138
      ANA_SIZE    =  23

      class SrcChCoder(gr.basic_block):
          SrcCoderlib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Transmitter/libs/tetraSrcCoderLib.so')

          # C-type corresponding to numpy array 
          ND_POINTER = np.ctypeslib.ndpointer(dtype=np.int16, 
                                                ndim=1,
                                                flags="C")
          SrcCoderlib.Pre_Process.argtypes = [ND_POINTER, c_int16]
          SrcCoderlib.Prm2bits_Tetra.argtypes = [ND_POINTER, ND_POINTER]
          SrcCoderlib.Coder_Tetra.argtypes    = [ND_POINTER, ND_POINTER]
          SrcCoderlib.Post_Process.argtypes   = [ND_POINTER, c_int16]

          SrcCoderlib.Copy_Speech_Frame.argtypes   = [ND_POINTER]
          def Copy_Speech_Frame(speech_frame):
              SrcChCoder.SrcCoderlib.Copy_Speech_Frame(speech_frame)

          def Init_Pre_Process():
              SrcChCoder.SrcCoderlib.Init_Pre_Process()

          def Init_Coder_Tetra():
              SrcChCoder.SrcCoderlib.Init_Coder_Tetra()
              
          def Pre_Process(new_speech, L_frame):
              SrcChCoder.SrcCoderlib.Pre_Process(new_speech, L_frame)

          def Prm2bits_Tetra(ana, serial):
              SrcChCoder.SrcCoderlib.Prm2bits_Tetra(ana, serial)

          def Coder_Tetra(ana, syn):
              SrcChCoder.SrcCoderlib.Coder_Tetra(ana, syn)

          def Post_Process(synth, L_frame):    
              SrcChCoder.SrcCoderlib.Post_Process(synth, L_frame)

          ChCoderlib = cdll.LoadLibrary('/home/ctn008/tetraDMO-Transmitter/libs/tetraChCoderLib.so')

          ChCoderlib.Channel_Encoding.argtypes    = [c_int16, c_int16, ND_POINTER, ND_POINTER]
          ChCoderlib.Interleaving_Signalling.argtypes = [ND_POINTER, ND_POINTER]
          ChCoderlib.Interleaving_Signalling.restype  = c_int16
          ChCoderlib.Interleaving_Speech.argtypes     = [ND_POINTER, ND_POINTER]
          ChCoderlib.Interleaving_Speech.restype      = c_int16

          def Channel_Encoding(first_pass, FS_Flag, Vocod_array, Coded_array):
              SrcChCoder.ChCoderlib.Channel_Encoding(first_pass,FS_Flag,Vocod_array,Coded_array)

          def Interleaving_Signalling( Input_Frame, Output_frame ):
              return SrcChCoder.ChCoderlib.Interleaving_Signalling( Input_Frame, Output_frame )

          def Interleaving_Speech( Input_Frame, Output_frame ):
              return SrcChCoder.ChCoderlib.Interleaving_Speech( Input_Frame, Output_frame )
          
          def __init__(self, mic_gain = 1):
              gr.basic_block.__init__(
                  self,
                  name='Tetra Voice Coder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              self.mic_gain = mic_gain
              
              self.syn    = np.array([0]*L_FRAME,     dtype = 'int16')
              self.ana    = np.array([0]*ANA_SIZE,    dtype = 'int16')    #/* Analysis parameters.   */
              self.serial = np.array([0]*SERIAL_SIZE, dtype = 'int16') #/* Serial stream.         */

              self.Loop_counter = 0
              self.first_pass = True
              self.FS_Flag = False
              self.Vocod_array         = np.array([0]*274, dtype = 'int16')
              self.Coded_array             = np.array([0]*432, dtype = 'int16')
              self.Interleaved_coded_array = np.array([0]*432, dtype = 'int16')

              SrcChCoder.Init_Pre_Process()
              SrcChCoder.Init_Coder_Tetra()
           
          def general_work(self, input_items, output_items):
              in_index = 0
              out_index = 0

              frame = 0

              while (len(input_items[0]) >= in_index + IN_STEP) and (len(output_items[0]) >= out_index + OUT_STEP) :
                  # multiply 32768 to convert from floating to int16
                  new_speech = np.array(input_items[0][in_index:in_index+480]*32768 * self.mic_gain, dtype = 'int16')
                  # process 1st 240 samples
                  SrcChCoder.Pre_Process(new_speech, L_FRAME)
                  SrcChCoder.Copy_Speech_Frame(new_speech)    # copy to c global 'new_speech' pointer
                  SrcChCoder.Coder_Tetra(self.ana, self.syn)
                  SrcChCoder.Post_Process(self.syn, L_FRAME)
                  SrcChCoder.Prm2bits_Tetra(self.ana, self.serial)
                  self.Vocod_array[  0:137] = self.serial[1:SERIAL_SIZE]
                  
                  # process next 240 samples
                  SrcChCoder.Pre_Process(new_speech[240:], L_FRAME)
                  SrcChCoder.Copy_Speech_Frame(new_speech[240:])    # copy to c global 'new_speech' pointer
                  SrcChCoder.Coder_Tetra(self.ana, self.syn)
                  SrcChCoder.Post_Process(self.syn, L_FRAME)
                  SrcChCoder.Prm2bits_Tetra(self.ana, self.serial)
                  self.Vocod_array[137:274] = self.serial[1:SERIAL_SIZE]

                  SrcChCoder.Channel_Encoding(self.first_pass, self.FS_Flag, self.Vocod_array, self.Coded_array)
                  self.first_pass = False

                  if (not self.FS_Flag):
                      SrcChCoder.Interleaving_Speech(self.Coded_array, self.Interleaved_coded_array)
                  else:
                      SrcChCoder.Interleaving_Signalling( self.Coded_array[216:], self.Interleaved_coded_array[216:] )
                      self.Interleaved_coded_array[0:216] = self.Coded_array[0:216]
                      print("FS_Flag ON")
                          
                  self.Loop_counter += 1

                  if type(output_items[0][0]) == np.int16:
                      output_items[0][out_index:out_index+432] = self.Interleaved_coded_array
                  else: #uint8
                      for i in range(432):
                          output_items[0][out_index+i] = 0 if (self.Interleaved_coded_array[i] == 127) else 1

                  in_index += IN_STEP
                  out_index += OUT_STEP
                  
              self.consume(0, in_index)
              return out_index
    mic_gain: '4'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class Pi4DQPSK(gr.interp_block):
          # Create our raised-cosine filter
          num_taps = 11 * 2 + 1
          beta = 0.35
          Ts = 2
          t = np.arange(num_taps) - (num_taps-1) // 2
          h = np.sinc(t/Ts) * np.cos(np.pi*beta*t/Ts) / (1 - (2*beta*t/Ts)**2)
          preConvI = np.array([0] * 22, dtype = 'float32')
          preConvQ = np.array([0] * 22, dtype = 'float32')
          
          def __init__(self, envelope_in = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.interp_block.__init__(
                  self,
                  name='Pi4DQPSK 18kDibit-to-36kIQk',   	# will show up in GRC
                  in_sig=[np.uint8, np.uint8,],
                  out_sig=[np.complex64], interp = 2
              )
              self.interp = 2        
              self.cur_phase_index = 	0				# current phase index value S(0) = 1
              self.envelope_in = envelope_in
              
          def work(self, input_items, output_items):
              # Phase Index Change Table: corresponding to current phase (row 0-7) and current dibit value (column 0-3)
              # B2k_1,B2k:   00 01 10 11
                  
              phase_shift = (1, 3, 7, 5)

              # Phase value corresponding to Phase Index
              IQ_table = (( np.cos(np.pi/4 * 0) , np.sin(np.pi/4 * 0) ),
                          ( np.cos(np.pi/4 * 1) , np.sin(np.pi/4 * 1) ),
                          ( np.cos(np.pi/4 * 2) , np.sin(np.pi/4 * 2) ),
                          ( np.cos(np.pi/4 * 3) , np.sin(np.pi/4 * 3) ),
                          ( np.cos(np.pi/4 * 4) , np.sin(np.pi/4 * 4) ),
                          ( np.cos(np.pi/4 * 5) , np.sin(np.pi/4 * 5) ),
                          ( np.cos(np.pi/4 * 6) , np.sin(np.pi/4 * 6) ),
                          ( np.cos(np.pi/4 * 7) , np.sin(np.pi/4 * 7) ))

              # perform rrc filter
              tempI = np.array([0] * (len(input_items[0]) * 2), dtype='float32') # 22 = rrc_taps - 1
              tempQ = np.array([0] * (len(input_items[0]) * 2), dtype='float32') # 22 = rrc_taps - 1

              for i in range (0,len(input_items[0])):
                  if self.envelope_in:
                      input_dibit = input_items[0][i] & input_items[1][i]
                  else:
                      input_dibit = input_items[0][i]
                      
                  self.cur_phase_index += phase_shift[ input_dibit ]
                  if self.cur_phase_index >= 8:
                      self.cur_phase_index -= 8

                  if input_items[1][i] :
                      tempI[i*2] = IQ_table[ self.cur_phase_index ][0]
                      tempQ[i*2] = IQ_table[ self.cur_phase_index ][1]

              tempIconvolved = np.convolve(tempI, Pi4DQPSK.h) 
              tempQconvolved = np.convolve(tempQ, Pi4DQPSK.h)
              
              for i in range(len(Pi4DQPSK.h)-1):
                  tempIconvolved[i] += Pi4DQPSK.preConvI[i]
                  tempQconvolved[i] += Pi4DQPSK.preConvQ[i]

              for i in range(len(Pi4DQPSK.h)-1):
                  Pi4DQPSK.preConvI[-i-1] = tempIconvolved[-i-1]
                  Pi4DQPSK.preConvQ[-i-1] = tempQconvolved[-i-1]
              for i in range(len(input_items[0])*2):
                  output_items[0][i] = tempIconvolved [i] + 1j*tempQconvolved[i]
                                         
              return len(output_items[0])
    envelope_in: 'False'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '2000000'
    buffer_size: int(32768)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: frequency_hz+freq_adjust
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    gain: decim/2
    interp: decim
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 36/80
    type: complex
  states: {}
- name: qtgui_ledindicator_0_0_1
  id: qtgui_ledindicator
  parameters:
    gui_hint: 0,4
    label: Transmit
    offColor: gray
    state: ptt_on
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"FrameView - 2040 bit "'
    size: 2040*2
    srate: audio_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: int(2*2040*720/36)
    srate: samp_rate
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    size: int(4*2040)
    srate: symbol_rate*2
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: s18kDibit
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: s18kDibit_envelop
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: s18kDibit
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: s18kDibit_envelop
  states: {}

connections:
- [audio_source_0, '0', epy_block_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, '0', virtual_sink_0, '0']
- [epy_block_0, '1', virtual_sink_0_0, '0']
- [epy_block_0_0, '0', epy_block_0, '0']
- [epy_block_1, '0', mmse_resampler_xx_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1_0_0, '0']
- [low_pass_filter_0_0, '0', iio_pluto_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [mmse_resampler_xx_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0, '0', epy_block_1, '0']
- [virtual_source_0_0, '0', epy_block_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
